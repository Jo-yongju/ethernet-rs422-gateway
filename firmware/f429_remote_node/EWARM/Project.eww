<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\f429_remote_node.ewp</path>
  </project>
  <batchBuild />
</workspace>
